# IAR project test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F103xB; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: D:\libraries\C&C++\Embedded_C99\Microcontroller\stm32f10x\test_lib\stm32f103c8t6\include; D:\libraries\C&C++\Embedded_C99\Microcontroller\stm32f10x\driver\include; D:\libraries\C&C++\Embedded_C99\Microcontroller\0_common\include; D:\libraries\C&C++\Embedded_C99\Microcontroller\1_Application\include; D:\libraries\Manufacturer_Package\No.0_C&C++_Industrial_Draft\Embedded_C99\Microcontroller\stm32f10x\driver\include; D:\libraries\Manufacturer_Package\No.0_C&C++_Industrial_Draft\Embedded_C99\Microcontroller\0_common\include; D:\libraries\Manufacturer_Package\STM32CubeF1\Drivers\STM32F1xx_HAL_Driver\Inc; D:\libraries\Manufacturer_Package\STM32CubeF1\Drivers\CMSIS\Device\ST\STM32F1xx\Include; D:\libraries\Manufacturer_Package\STM32CubeF1\Drivers\CMSIS\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: test.srec
  ILINK.IlinkOutputFile: test.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration Debug_Vendor (ARM, debug)
  as the first configuration, except:
configuration DMA_B12_S01_HAL (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F103xB; USE_HAL_DRIVER; USE_FULL_LL_DRIVER
configuration DMA_B12_S02_03_BareMetal (ARM, debug)
  as the first configuration, except:
configuration DMA_B12_HAL (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F103xB; USE_HAL_DRIVER; USE_FULL_LL_DRIVER
  group (top)
    ../../driver/include/: base_timer.h basic_timer.h general_timer.h
    source/: cortex_m3.c
    include/: cortex_m3.h stm32f103c8t6.h
    ../../../1_Application/: dma_fsm_button.c dma_fsm_led.c dma_fsm_time.c
  group Application
    include/: advanced_timer.h base_timer.h basic_timer.h general_timer.h
    ../../../1_Application/button/: button.c fsm_button.c
    ../../../1_Application/led/: fsm_led.c led.c
    source/: gemini-main_b12_app_hal.c main.c main_b12_A_S01.c main_b12_A_S02.c main_b12_A_S03.c main_b12_B_S01.c main_b12_B_S02.c main_b12_B_S03.c main_buoi11_tim1.c startup_stm32f103cx.s
    ../../driver/: gpio.c
    ../../../../../../Manufacturer_Package/No.0_C&C++_Industrial_Draft/Embedded_C99/Microcontroller/1_Application/: main_buoi12_0_test.c
  group Driver
    ../../driver/include/: bitband.h exti.h flash.c flash.h fsm_time.h gpio.h i2c.h pwr.h rcc.h rtc.h spi.h uart.h
    ../../../1_Application/include/: button.h fsm_button.h fsm_led.h led.h
    ../../../0_common/include/: common.h define.h
    include/: config.h
    ../../driver/: fsm_time.c
    ../../../1_Application/: gemini-dma_fsm_button.c gemini-dma_fsm_led.c gemini-dma_fsm_time.c
    C:/Users/Chien/Downloads/Libraries-20250820T153814Z-1-001/Libraries/C&C++/embedded_C99/Microcontroler/STM32F10x/: stm32f103c8t6.h
  group Vendor_HAL
    ../../../../../../Manufacturer_Package/No.0_C&C++_Industrial_Draft/Embedded_C99/Microcontroller/stm32f10x/driver/: stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_tim.c
  group Vendor_LL
    ../../../../../../Manufacturer_Package/No.0_C&C++_Industrial_Draft/Embedded_C99/Microcontroller/stm32f10x/driver/: stm32f1xx_ll_exti.c stm32f1xx_ll_gpio.c stm32f1xx_ll_tim.c
